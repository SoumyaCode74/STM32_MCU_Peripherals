# Keil uVision project SPI_Keil.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_Keil
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./Src/: main.c syscalls.c sysmem.c
    ./Inc/: cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm4.h mpu_armv7.h stm32f429xx.h stm32f429xx_general.h stm32f429xx_gpio_driver.h stm32f429xx_rcc_driver.h system_stm32f4xx.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
